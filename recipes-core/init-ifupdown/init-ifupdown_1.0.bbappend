FILESEXTRAPATHS:prepend:openstlinuxcommonrt := "${THISDIR}/init-ifupdown-1.0:"
