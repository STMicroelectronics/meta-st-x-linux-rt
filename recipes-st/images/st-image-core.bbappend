IMAGE_INSTALL:append:stm32mprtcommon = " rt-tests hwlatdetect"
